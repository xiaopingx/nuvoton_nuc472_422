# Keil uVision project nuc422_472_module.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: nuc422_472_module
  AfterMake: fromelf --bin "..\Objects\@L.axf" --output "..\Objects\@L.bin"
  AfterMake: fromelf --text -c "..\Objects\@L.axf" --output "..\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\SystemCode\nuc442_472
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_NUC472_442.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Source Group 1
    ../SystemCode/nuc442_472/: startup_NUC472_442.s
  group SystemCode
    ../SystemCode/nuc442_472/: clk.c sys.c system_NUC472_442.c
    ../SystemCode/delay/: delay.c
  group USER
    ../ProjectCode/: main.c
